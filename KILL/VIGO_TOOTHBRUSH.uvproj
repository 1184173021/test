# Keil uVision project VIGO_TOOTHBRUSH.uvproj, settings and files
target VIGO_TOOTHBRUSH (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: VIGO_TOOTHBRUSH
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP;..\COMMON
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ../APP/: main.c proces_mode.c
  group BSP
    ../BSP/: key.c LED.c PWM.c uart.c
  group COMMON
    ../COMMON/: Delay.c
